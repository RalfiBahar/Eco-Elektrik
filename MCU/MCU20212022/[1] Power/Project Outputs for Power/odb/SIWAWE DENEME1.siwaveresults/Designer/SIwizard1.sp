* Netlist generated by SIwave - SI wizard
* SIwave Project: SIWAWE DENEME1

.model ModelTS S TSTONEFILE="C:/Users/guven/Desktop/-AESK-/ALL Documents/Drive Electric 2020/Elektrik/Motor Driver/BLDC Driver/[1] Hardware/[1] Power/Project Outputs for Power/odb/SIWAWE DENEME1.siwaveresults/Designer/SIwizard1.s6p" INTERPOLATION=LINEAR INTDATTYP=MA HIGHPASS=10 LOWPASS=10 convolution=0 enforce_passivity=0 Noisemodel=External
S1 CS_PHASE_A_3_1x3_PIN_PHASE_A CS_PHASE_A_3_ACS770LCB-050B-PFF-T_U1 CS_PHASE_B_3_1x3_PIN_PHASE_B CS_PHASE_B_3_ACS770LCB-050B-PFF-T_U3 CS_PHASE_C_3_1x3_PIN_PHASE_C CS_PHASE_C_3_ACS770LCB-050B-PFF-T_U4 FQMODEL="ModelTS"
* RECEIVER0
AEYEPROBE1 n1 COMPONENT=EYE_PROBE SOURCE_NAME=AEYESOURCEEYESRC0
Rterm1 n1 0 50
Vcnct1 n1 CS_PHASE_B_3_1x3_PIN_PHASE_B DC 0

* RECEIVER1
AEYEPROBE2 n2 COMPONENT=EYE_PROBE SOURCE_NAME=AEYESOURCEEYESRC1
Rterm2 n2 0 50
Vcnct2 n2 CS_PHASE_B_3_ACS770LCB-050B-PFF-T_U3 DC 0

* RECEIVER2
AEYEPROBE3 n3 COMPONENT=EYE_PROBE SOURCE_NAME=AEYESOURCEEYESRC2
Rterm3 n3 0 50
Vcnct3 n3 CS_PHASE_A_3_1x3_PIN_PHASE_A DC 0

* RECEIVER3
AEYEPROBE4 n4 COMPONENT=EYE_PROBE SOURCE_NAME=AEYESOURCEEYESRC3
Rterm4 n4 0 50
Vcnct4 n4 CS_PHASE_A_3_ACS770LCB-050B-PFF-T_U1 DC 0

* RECEIVER4
AEYEPROBE5 n5 COMPONENT=EYE_PROBE SOURCE_NAME=AEYESOURCEEYESRC4
Rterm5 n5 0 50
Vcnct5 n5 CS_PHASE_C_3_1x3_PIN_PHASE_C DC 0

* RECEIVER5
AEYEPROBE6 n6 COMPONENT=EYE_PROBE SOURCE_NAME=AEYESOURCEEYESRC5
Rterm6 n6 0 50
Vcnct6 n6 CS_PHASE_C_3_ACS770LCB-050B-PFF-T_U4 DC 0

.option num_threads=4
.TRAN 1E-10 2.5E-08
.print TRAN V(*)
